# IAR project StreamingTransmitter.ewp, settings and files
configuration Release (STM8)
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG; STM8S005; BRD_RADIO_TYPE=3
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: StreamingTransmitter.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Debug_Beken (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S005K6 STM8S005K6
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S005; BRD_RADIO_TYPE=3
  ICCSTM8.CCIncludePath2: ..\include
  OBJCOPY.OOCOutputFile: StreamingTransmitter.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: lnkstm8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_CC2500 (STM8, debug)
  as the first configuration, except:
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105; BRD_RADIO_TYPE=2
  ICCSTM8.CCIncludePath2: ..\include
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: lnkstm8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Cypress (STM8, debug)
  as the first configuration, except:
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105; BRD_RADIO_TYPE=1
  ICCSTM8.CCIncludePath2: ..\include
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: lnkstm8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../txmain/: main.c
  group Include
    ../include/: adc.h buzzer.h channels.h config.h crc.h cypress.h eeprom.h gpio.h spi.h stm8l.h telem_structure.h timer.h uart.h util.h
  group Lib
    ../lib/: adc.c beken.c buzzer.c cc2500.c channels.c crc.c cypress.c eeprom.c gpio.c printfl.c spi.c timer.c uart.c util.c
