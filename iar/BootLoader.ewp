# IAR project BootLoader.ewp, settings and files
configuration BootDebug_Beken (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K6 STM8S105K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105; PRODUCT=2
  ICCSTM8.CCIncludePath2: ..\include
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: BootLoader.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration BootRelease_Beken (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ../lib/: crc.c eeprom.c gpio.c
    ../bootloader/: main.c
