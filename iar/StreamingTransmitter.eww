<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Blank.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\BootLoader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\StreamingTransmitter.ewp</path>
  </project>
  <batchBuild/>
</workspace>


